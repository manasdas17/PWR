<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>FM_file_sink</value></param>
<param><key>file</key><value>FM_data.cmplx</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_wfm_tx</key>
<param><key>id</key><value>FM_modulator</value></param>
<param><key>audio_rate</key><value>32000</value></param>
<param><key>quad_rate</key><value>32000</value></param>
<param><key>tau</key><value>75e-6</value></param>
<param><key>max_dev</key><value>75e3</value></param>
</block>
<block>
<key>gr_noise_source_x</key>
<param><key>id</key><value>gr_noise_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>noise_type</key><value>gr.GR_GAUSSIAN</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>seed</key><value>42</value></param>
</block>
<block>
<key>gr_throttle</key>
<param><key>id</key><value>gr_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>FM_monitor</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>50</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>30</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
</block>
<connection><source_block_id>gr_noise_source_x_0</source_block_id><sink_block_id>FM_modulator</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>FM_modulator</source_block_id><sink_block_id>gr_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_throttle_0</source_block_id><sink_block_id>FM_file_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_throttle_0</source_block_id><sink_block_id>FM_monitor</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
